options:
  parameters:
    author: priyanka
    generate_options: hb
    id: ofdm_pb
    output_language: python
    title: ofdmpb
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    num_streams: '3'
    type: complex
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '2'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(2)
  states: {state: disabled}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '2'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: tap0
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: tap1
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {state: disabled}

connections:
- [blocks_deinterleave_0_0, '0', blocks_null_sink_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_interleave_0_0, '0']
- [blocks_deinterleave_0_0, '2', blocks_interleave_0_0, '1']
- [blocks_interleave_0, '0', pad_sink_0_0, '0']
- [blocks_interleave_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_streams_0, '1', blocks_interleave_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_interleave_0, '2']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_streams_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
